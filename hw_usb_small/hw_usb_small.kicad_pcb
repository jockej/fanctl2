# Repository jockej/fanctl2

File README.md:

# fanctl2
Another fancontroller

## KiCad design hw_usb_small/hw_usb_small.kicad_pcb

Parts:
C1, C2, C3, C4: C; C_Disc_D3_P2.5
D1: D; Diode_DO-35_SOD27_Horizontal_RM10
D2, D3: ZENER; Diode_DO-35_SOD27_Horizontal_RM10
D4, D5, D6: LED; LED-5MM
FAN1: 4PIN_FAN; AB2_HDR_M04-1V_CPU_FAN
IC1: ATTINY85-P; DIP-8_W7.62mm
ICSP1: Prog_con; Pin_Header_Straight_2x03
JP1, JP3, JP4, JP5: JUMPER3; Pin_Header_Straight_1x03
JP2: Jumper_NO_Small; Pin_Header_Straight_1x02
P1: CONN_01X02; Pin_Header_Straight_1x02
P2: MOLEX_PWR; AB2_ATX_PSU-4PIN-V
Q1: FAN_NMOS; TO-220_Neutral123_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: FANCTL2_R; Resistor_Horizontal_RM10mm
U1: LTV-827; DIP-8_W7.62mm
USB1: USB_HDR; Pin_Header_Straight_1x04

Connections:
5VMOLEX: C4.1, D5.2 (A), JP4.3, P2.4
5VMOLEXGND: C4.2, JP5.3, P2.3, R13.1
12VGND: C2.2, D1.2 (A), D6.1 (K), FAN1.1 (GND), P2.2
+5V: C1.1, C3.2, D4.2 (A), IC1.8 (VCC), ICSP1.2 (VCC), JP4.1, R2.2, R5.2, R10.1, R11.1, USB1.4 (+5V)
+12V: C2.1, P2.1, Q1.1 (S), R14.2
FAN5V: JP4.2, R6.1, U1.8
FAN5VGND: JP5.2, R1.2, R3.1
GND: C1.2, C3.1, D2.2 (A), D3.2 (A), IC1.4 (GND), ICSP1.6 (GND), JP2.1, JP5.1, P1.1, R4.1, R8.2, R12.1, USB1.1 (GND)
unnamed: D1.1 (K), FAN1.2 (12V), Q1.2 (D)
unnamed: D2.1 (K), R7.1, R11.2, USB1.3 (D-)
unnamed: D3.1 (K), R9.1, USB1.2 (D+)
unnamed: D4.1 (K), R12.2
unnamed: D5.1 (K), R13.2
unnamed: D6.2 (A), R14.1
unnamed: FAN1.4 (PWM), JP1.2
unnamed: IC1.1 (PB5(~RESET~/dW/ADC0/PCINT5)), ICSP1.5 (RST), JP2.2, R5.1
unnamed: IC1.3 (PB4(XTAL2/CLKO/OC1B/ADC2/PCINT4)), P1.2, R10.2
unnamed: IC1.5 (PB0(MOSI/DI/SDA/AIN0/OC0A/OC1A/AREF/PCI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), ICSP1.4 (MOSI), U1.1
unnamed: IC1.6 (PB1(MISO/DO/AIN1/OC0B/OC1A/PCINT1)), ICSP1.1 (MISO), R7.2
unnamed: IC1.7 (PB2(SCK/USCK/SCL/T0/INT0/ADC1/PCINT2)), ICSP1.3 (SCK), R9.2
unnamed: JP1.1, JP3.3, R3.2, U1.7
unnamed: JP1.3, JP3.1, R6.2
unnamed: JP3.2, Q1.3 (G)
unnamed: R1.1, U1.4
unnamed: R2.1, U1.5
unnamed: R4.2, U1.2
TACHIN: IC1.2 (PB3(XTAL1/CLKI/OC1B/ADC3/PCINT3)), R8.1, U1.6
TACHOUT: FAN1.3 (TACH), U1.3

Board: 2 copper layers, 37 parts (0 on the bottom side), 28 nets, no tracks yet.

## KiCad design hw/fanctl2.kicad_pcb

Parts:
C0, C1, C2, C3, C4, C5, C8, C9, C13, C14: 0.1u; C_Disc_D3_P2.5
C6, C7: 22p; C_Disc_D3_P2.5
C10, C12: C; C_Disc_D3_P2.5
C11: Decoupler; C_Disc_D3_P2.5
C15: 22n; C_Disc_D3_P2.5
D0, D1, D2, D3, D4, D5: D; Diode_DO-35_SOD27_Horizontal_RM10
D6, D7, D8, D9, D10: LED; LED-5MM
D11, D12: ZENER; Diode_DO-35_SOD27_Horizontal_RM10
F1: F_Small; Resistor_Horizontal_RM10mm
FAN0, FAN1, FAN2, FAN3, FAN4, FAN5: 4PIN_FAN; AB2_HDR_M04-1V_CPU_FAN
I2C0: I2C_HDR; Pin_Header_Straight_2x02
ICSP0: Prog_con; Pin_Header_Straight_2x03
JP0, JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11: JUMPER3; Pin_Header_Straight_1x03
JP12: Jumper_NO_Small; Pin_Header_Straight_1x02
L1: 10uH; INDUCTOR_V; Manu1 part no RL622-100K-RC
MCU0: ATMEGA168PA-P; DIP-28_W7.62mm
MPLX0: Multiplexer_16:1; DIP-24_W7.62mm; Manu1 part no CD47HC4067E
P0: CONN_01X03; Pin_Header_Straight_1x03
P1: MOLEX_PWR; AB2_ATX_PSU-4PIN-V
P2, P3, P4: CONN_01X04; Pin_Header_Straight_1x04
Q1, Q2, Q3, Q4, Q5, Q7: FAN_NMOS; TO-220_Neutral123_Vertical
Q6: BC413; TO-92_Inline_Narrow_Oval; Manu1 part no BC547BTA
R1, R6: 10K; Resistor_Horizontal_RM10mm
R2, R4: 10k; Resistor_Horizontal_RM10mm
R3, R5: R; Resistor_Horizontal_RM10mm
R7, R8: 68; Resistor_Horizontal_RM10mm
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22: FANCTL2_R; Resistor_Horizontal_RM10mm
RR1: RR8; SIP9_Housing
TEMP1: TMP_SNSR_HDR; Pin_Header_Straight_2x08
U1: 7400; DIP-14_W7.62mm; Manu1 part no SN74LS00N
U2: LM358; DIP-8_W7.62mm
U3: P82B96; DIP-8_W7.62mm
USB0: USB_HDR; Pin_Header_Angled_1x04
Y0: Crystal_Small; Crystal_HC49-U_Vertical; Manu1 part no 9B-12.000MEEJ-B

Connections:
12VGND: C0.2, C1.2, C2.2, C3.2, C4.2, C5.2, C11.1, D0.2 (A), D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.1 (K), FAN0.1 (GND), FAN1.1 (GND), FAN2.1 (GND), FAN3.1 (GND), FAN4.1 (GND), FAN5.1 (GND), P2.1, P3.1, P4.1, R3.2, U2.5 (+)
+5V: C8.1, C14.2, C15.1, D7.2 (A), I2C0.2 (+5V), ICSP0.2 (VCC), L1.1, MCU0.7 (VCC), MPLX0.24, Q6.1 (C), R1.1, R2.1, R5.1, R6.1, R10.2, R15.2, R21.1, R22.1, U2.8 (V+), U3.8 (VCC)
+12V: C0.1, C1.1, C2.1, C3.1, C4.1, C5.1, F1.1, P2.4, P3.4, P4.4, Q1.2 (D), Q2.2 (D), Q3.2 (D), Q4.2 (D), Q5.2 (D), Q7.2 (D), R14.1, R19.2, R20.2
COM5V: JP0.1, JP1.3, JP2.1, JP3.3, JP4.1, JP5.3, JP6.1, JP7.3, JP8.1, JP9.3, JP10.1, JP11.3, R1.2
GND: C6.1, C7.1, C8.2, C9.2, C13.2, C14.1, C15.2, D11.2 (A), D12.2 (A), I2C0.4 (GND), ICSP0.6 (GND), JP12.1, MCU0.8 (GND), MCU0.22 (GND), MPLX0.12, P0.3, P1.2, R3.1, R4.1, R9.2, R11.1, R12.1, R13.1, R17.2, TEMP1.2, TEMP1.4, TEMP1.6, TEMP1.8, TEMP1.10, TEMP1.12, TEMP1.14, TEMP1.16, U1.7 (GND), U2.4 (V-), U3.4 (GND)
I5V: C10.1, MPLX0.17, R16.1, U2.1
I12V: C12.2, MPLX0.16, R18.1, U2.7
LED0: D8.2 (A), MCU0.26 ((PCINT11/ADC3)PC3)
LED1: D9.2 (A), MCU0.25 ((PCINT10/ADC2)PC2)
LED2: D10.2 (A), MCU0.13 ((PCINT23/AIN1)PD7)
unnamed: C6.2, MCU0.10 ((PCINT7/XTAL2/TOSC2)PB7), Y0.2
unnamed: C7.2, MCU0.9 ((PCINT6/XTAL1/TOSC1)PB6), Y0.1
unnamed: C9.1, L1.2, MCU0.20 (AVCC), MCU0.21 (AREF)
unnamed: C10.2, R15.1, R16.2, U2.2 (-)
unnamed: C11.2, F1.2, P1.1
unnamed: C12.1, R17.1, R18.2, U2.6 (-)
unnamed: C13.1, R5.2, U2.3 (+), USB0.4 (+5V)
unnamed: D0.1 (K), FAN0.2 (12V), Q7.1 (S)
unnamed: D1.1 (K), FAN1.2 (12V), Q1.1 (S)
unnamed: D2.1 (K), FAN2.2 (12V), Q2.1 (S)
unnamed: D3.1 (K), FAN3.2 (12V), Q3.1 (S)
unnamed: D4.1 (K), FAN4.2 (12V), Q4.1 (S)
unnamed: D5.1 (K), FAN5.2 (12V), Q5.1 (S)
unnamed: D6.2 (A), R14.2
unnamed: D7.1 (K), R9.1
unnamed: D8.1 (K), R11.2
unnamed: D9.1 (K), R12.2
unnamed: D10.1 (K), R13.2
unnamed: D11.1 (K), R8.1, R10.1, USB0.3 (D-)
unnamed: D12.1 (K), R7.1, USB0.2 (D+)
unnamed: FAN0.4 (PWM), JP0.2
unnamed: FAN1.4 (PWM), JP2.2
unnamed: FAN2.4 (PWM), JP4.2
unnamed: FAN3.4 (PWM), JP6.2
unnamed: FAN4.4 (PWM), JP8.2
unnamed: FAN5.4 (PWM), JP10.2
unnamed: ICSP0.5 (RST), JP12.2, MCU0.1 ((PCINT14/~RESET~)PC6), R6.2
unnamed: JP1.2, Q7.3 (G)
unnamed: JP3.2, Q1.3 (G)
unnamed: JP5.2, Q2.3 (G)
unnamed: JP7.2, Q3.3 (G)
unnamed: JP9.2, Q4.3 (G)
unnamed: JP11.2, Q5.3 (G)
unnamed: MCU0.2 ((PCINT16/RXD)PD0), P0.2
unnamed: MCU0.3 ((PCINT17/TXD)PD1), P0.1
unnamed: MCU0.4 ((PCINT18/INT0)PD2), R7.2
unnamed: MCU0.6 ((PCINT20/XCK/T0)PD4), R8.2
unnamed: MPLX0.2, RR1.8, TEMP1.3
unnamed: MPLX0.3, RR1.9, TEMP1.1
unnamed: MPLX0.15, R2.2
unnamed: MPLX0.18, RR1.2, TEMP1.15
unnamed: MPLX0.19, RR1.3, TEMP1.13
unnamed: MPLX0.20, RR1.4, TEMP1.11
unnamed: MPLX0.21, RR1.5, TEMP1.9
unnamed: MPLX0.22, RR1.6, TEMP1.7
unnamed: MPLX0.23, RR1.7, TEMP1.5
unnamed: P2.2, P3.2, P4.2, R20.1, U3.2 (RXD-SDA), U3.3 (TXD-SDA)
unnamed: P2.3, P3.3, P4.3, R19.1, U3.5 (TXD-SCL), U3.6 (RXD-SCL)
unnamed: Q6.2 (B), R4.2, U1.8
unnamed: Q6.3 (E), RR1.1 (COM)
unnamed: U1.3, U1.4, U1.5
unnamed: U1.6, U1.9
PWM0: ICSP0.4 (MOSI), JP0.3, JP1.1, MCU0.17 ((PCINT3/OC2A/MOSI)PB3)
PWM1: JP2.3, JP3.1, MCU0.16 ((PCINT2/OC1B/~SS~)PB2)
PWM2: JP4.3, JP5.1, MCU0.15 ((PCINT1/OC1A)PB1)
PWM3: JP6.3, JP7.1, MCU0.5 ((PCINT19/OC2B/INT1)PD3)
PWM4: JP8.3, JP9.1, MCU0.11 ((PCINT21/OC0B/T1)PD5)
PWM5: JP10.3, JP11.1, MCU0.12 ((PCINT22/OC0A/AIN0)PD6)
SCL: I2C0.1 (SCL), MCU0.28 ((PCINT13/SCL/ADC5)PC5), R21.2, U3.7 (SCL)
SDA: I2C0.3 (SDA), MCU0.27 ((PCINT12/SDA/ADC4)PC4), R22.2, U3.1 (SDA)
SEL0: MCU0.14 ((PCINT0/CLKO/ICP1)PB0), MPLX0.10
SEL1: ICSP0.3 (SCK), MCU0.19 ((PCINT5/SCK)PB5), MPLX0.11, U1.1
SEL2: ICSP0.1 (MISO), MCU0.18 ((PCINT4/MISO)PB4), MPLX0.14, U1.2
SEL3: MCU0.24 ((PCINT9/ADC1)PC1), MPLX0.13, U1.10
SENS0: MCU0.23 ((PCINT8/ADC0)PC0), MPLX0.1
TACH0: FAN0.3 (TACH), MPLX0.9
TACH1: FAN1.3 (TACH), MPLX0.8
TACH2: FAN2.3 (TACH), MPLX0.7
TACH3: FAN3.3 (TACH), MPLX0.6
TACH4: FAN4.3 (TACH), MPLX0.5
TACH5: FAN5.3 (TACH), MPLX0.4
VCC: U1.14 (VCC)

Board: 2 copper layers, 95.9 x 76.2 mm, 99 parts (0 on the bottom side), 81 nets.

Other parts of the board:
H0, H1, H2, H3: MountingHole_3mm

## Commit log

2015-12-31 Started hw
2016-01-03 PCB pretty much done.
    I changed the size so it would be smaller than 10x10 cm, otherwise it's
    absurdly expensive to have it made.
2016-01-03 Add a resistor.
2016-01-04 Lots of changes
2016-01-08 Started on a small i2c slave
2016-01-18 Small one fan usb variant
2016-03-01 Tons of changes
2016-03-01 Remove all other variants
    I will make more repos instead
